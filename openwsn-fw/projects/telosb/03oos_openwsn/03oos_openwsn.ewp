# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 200
  General.GHeapSize2: 200
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc2420\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\telosb\; ..\..\..\drivers\; ..\..\..\drivers\common\; ..\..\..\drivers\telosb\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\kernel\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openstack\cross-layers\; ..\..\..\openapps\; ..\..\..\openapps\c6t\; ..\..\..\openapps\cinfo\; ..\..\..\openapps\cleds\; ..\..\..\openapps\cstorm\; ..\..\..\openapps\cwellknown\; ..\..\..\openapps\techo\; ..\..\..\openapps\tohlone\; ..\..\..\openapps\uecho\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h
  group bsp/boards/telosb
    ../../../bsp/boards/telosb/: board.c board_info.h bsp_timer.c debugpins.c eui64.c leds.c radiotimer.c spi.c uart.c
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/cc2420
    ../../../bsp/chips/cc2420/: cc2420.h radio.c
  group drivers
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/openos/: scheduler.c
    ../../../kernel/: scheduler.h
  group openapps
    ../../../openapps/: openapps.c
  group openapps/c6t
    ../../../openapps/c6t/: c6t.c c6t.h
  group openapps/cinfo
    ../../../openapps/cinfo/: cinfo.c cinfo.h
  group openapps/cleds
    ../../../openapps/cleds/: cleds.c cleds.h
  group openapps/cstorm
    ../../../openapps/cstorm/: cstorm.c cstorm.h
  group openapps/cwellknown
    ../../../openapps/cwellknown/: cwellknown.c cwellknown.h
  group openapps/techo
    ../../../openapps/techo/: techo.c techo.h
  group openapps/tohlone
    ../../../openapps/tohlone/: tohlone.c tohlone.h tohlone_webpages.c tohlone_webpages.h
  group openapps/uecho
    ../../../openapps/uecho/: uecho.c uecho.h
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c neighbors.h otf.c otf.h processIE.c processIE.h schedule.c schedule.h sixtop.c sixtop.h
  group openstack/03a-IPHC
    ../../../openstack/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group openstack/03b-IPv6
    ../../../openstack/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h
  group openstack/04-TRAN
    ../../../openstack/04-TRAN/: opencoap.c opencoap.h opentcp.c opentcp.h openudp.c openudp.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
